# Keil uVision project master_A.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: master_A +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: master_A.c STARTUP.A51
